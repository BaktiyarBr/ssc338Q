# Repository BaktiyarBr/ssc338Q

## KiCad design ssq338q_V1.kicad_pcb

Parts:
C41, C77: 10u; C_0603_1608Metric; Manufacturer Part CL10A106MA8NRNC
C42, C78, C79, C80, C81, C82, C86, C87: 100n; C_0402_1005Metric; Manufacturer Part CL05B104KB54PNC
C83, C84: 12p; C_0402_1005Metric; Manufacturer Part 0402CG200J500NT; LCSC Part Name C26406
C85: 100n; C_0402_1005Metric
DF2: DF56C-26S-0.3V(51); Manufacturer Part DF56C-26S-0.3V(51); LCSC Part Name C5338332
FB1: CBM160808U600T; R_0603_1608Metric
FB2: CBM160808U121T; R_0603_1608Metric
J4: Conn_01x04_MountingPin; JST_SH_SM04B-SRSS-TB_1x04-1MP_P1.00mm_Horizontal; LCSC Part Name C2936214
J6: Conn_01x06_MountingPin; JST_SH_SM06B-SRSS-TB_1x06-1MP_P1.00mm_Horizontal; LCSC Part Name C3041141
J7: Conn_01x03_MountingPin; JST_SH_SM03B-SRSS-TB_1x03-1MP_P1.00mm_Horizontal; LCSC Part Name C2936213
J8: Conn_01x02_MountingPin; JST_SH_SM02B-SRSS-TB_1x02-1MP_P1.00mm_Horizontal; LCSC Part Name C3041139
LED10, LED11, LED12: NCD0402G1; LED_0402_1005Metric; LCSC Part Name C30584803
R21, R22, R65, R74: 10k; R_0402_1005Metric
R45, R46, R62, R69, R70, R71: 4k7; R_0402_1005Metric
R47, R55: 22; R_0402_1005Metric
R48: 200k; R_0402_1005Metric
R49, R58, R59, R60, R61, R63, R64, R100: 100; R_0402_1005Metric
R50, R51, R52, R53, R54, R68: 4k7; R_0402_1005Metric; not fitted
R72: 100k; R_0402_1005Metric
SD2: TF-027-H300; TF-SMD_HYCW104-TF08-375B; Manufacturer Part TF-027-H300; LCSC Part Name C5310495
U2: SSC338Q; QFN128_12.3_12.3; LCSC Part Name taobao
U11: W25Q128JVSIQ; SOIC-8_L5.3-W5.3-P1.27-LS8.0-BL; Manufacturer Part W25Q128JVSIQ; LCSC Part Name C97521
U13: BL-M8812EU2; Manufacturer Part BL-M8812EU2; LCSC Part Name taobao
X2: 24MHz; Crystal_SMD_2016-4Pin_2.0x1.6mm; LCSC Part Name C2965580

Connections:
+1V0: U2.23 (VDD), U2.44 (DVDD_DDR), U2.45 (VDD), U2.47 (VDD), U2.87 (VDD), U2.88 (VDD), U2.96 (VDD), U2.115 (VDD), U2.120 (VDD); also elsewhere on the board
+1V5: U2.40 (AVDDIO_DRAM), U2.41 (AVDDIO_DATA), U2.46 (VDDIO_DATA), U2.48 (VDDIO_MCLK), U2.49 (VDDIO_DRAM); also elsewhere on the board
+1V8: C79.2, R45.2, R46.2, U2.97 (VDDP_2A); also elsewhere on the board
+3V3: C81.1, C85.2, C86.2, C87.1, DF2.1, DF2.3, DF2.5, FB2.1, LED11.2 (A), LED12.2 (A), R48.1, R50.1, R51.1, R52.1, R53.1, R54.1, R65.1, R69.1, R71.2, R74.1, SD2.4 (VDD), U2.24 (VDD_ETH), U2.29 (AVDD3P3_USB), U2.42 (AVDD_PLL), U2.65 (AVDD_NODIE), U2.72 (AVDD_PM_SPI), U2.84 (AVDD_RTC), U2.89 (VDDP_1), U2.116 (AVDD_XTAL), U2.127 (VDDP_0), U11.8 (VCC); also elsewhere on the board
+5V: J8.2, U13.6 (VDD5), U13.7 (VDD5); also elsewhere on the board
/ETH_LED0: U2.21 (ETH_LED0)
/ETH_LED1: U2.22 (ETH_LED1)
/ETH_RX+: J6.2, U2.26 (ETH_RP)
/ETH_RX-: J6.1, U2.25 (ETH_RN)
/ETH_TX+: J6.4, U2.28 (ETH_TP)
/ETH_TX-: J6.3, U2.27 (ETH_TN)
/FUART_RX: J4.3, R58.1
/FUART_TX: J4.4, R59.1
/GPIO0_LED1: R21.2, U2.56 (PM_GPIO0)
/GPIO1_LED2: U2.57 (PM_GPIO1)
/I2C0_SCL: U2.19 (I2C0_SCL)
/I2C0_SDA: U2.20 (I2C0_SCA)
/I2C1_SCL: DF2.24, R45.1, U2.113 (SR0_IO18)
/I2C1_SDA: DF2.26, R46.1, U2.114 (SR0_IO19)
/MIPI_CK+: DF2.18, U2.104 (SR0_IO6)
/MIPI_CK-: DF2.20, U2.105 (SR0_IO7)
/MIPI_D0+: DF2.2, U2.100 (SR0_IO2)
/MIPI_D0-: DF2.4, U2.101 (SR0_IO3)
/MIPI_D1+: DF2.8, U2.102 (SR0_IO4)
/MIPI_D1-: DF2.10, U2.103 (SR0_IO5)
/MIPI_D2+: DF2.17, U2.106 (SR0_IO8)
/MIPI_D2-: DF2.19, U2.107 (SR0_IO9)
/MIPI_D3+: DF2.23, U2.108 (SR0_IO10)
/MIPI_D3-: DF2.25, U2.109 (SR0_IO11)
/MIPI_MCLK: DF2.9, R47.2
/MIPI_RST: DF2.7, U2.111 (SR0_IO16)
/PM_GPIO2: U2.58 (PM_GPIO2)
/PM_GPIO3: U2.59 (PM_GPIO3)
/PM_GPIO5: U2.61 (PM_GPIO5)
/PM_GPIO6: R62.2, U2.62 (PM_GPIO6)
/PM_GPIO7: U2.63 (PM_GPIO7)
/PM_I2CM_SCL: U2.54 (PM_I2CM_SCL)
/PM_I2CM_SDA: U2.55 (PM_I2CM_SDA)
/PM_RESET: C86.1, R72.2, U2.83 (RESET)
/PM_SPI_HOLD: U2.71 (PM_SPI_HLD)
/PM_SPI_SCK: R71.1, U2.67 (PM_SPI_CK)
/PM_SPI_SDI: U2.68 (PM_SPI_DI)
/PM_SPI_SDO: U2.69 (PM_SPI_DO)
/PM_SPI_WPZ: R70.1, U2.70 (PM_SPI_WPZ)
/SD_CDZ: LED10.1 (C), R68.1, R69.2, SD2.9, U2.7 (SD0_CDZ)
/SD_CLK: R55.2, SD2.5 (CLK)
/SD_CMD: R53.2, SD2.3 (CMD), U2.11 (SD0_CMD)
/SD_DATA0: R52.2, SD2.7 (DAT0), U2.9 (SD0_D0)
/SD_DATA1: R54.2, SD2.8 (DAT1), U2.8 (SD0_D1)
/SD_DATA2: R50.2, SD2.1 (DAT2), U2.13 (SD0_D2)
/SD_DATA3: R51.2, SD2.2 (CD/DAT3), U2.12 (SD0_D3)
/SD_PWR_EN: U2.6 (SD0_GPIO0)
/SPI_CZ: U2.128 (SPI_CZ), U11.1 (CS#)
/SPI_HOLD: U2.5 (SPI_HLD), U11.7 (IO3)
/SPI_SCK: U2.1 (SPI_CK), U11.6 (CLK)
/SPI_SDI: U2.2 (SPI_DI), U11.5 (DI)
/SPI_SDO: U2.3 (SPI_DO), U11.2 (DO)
/SPI_WPZ: U2.4 (SPI_WPZ), U11.3 (IO2)
/SW_RST: C82.1, R65.2, U2.60 (PM_GPIO4)
/UART_RX0: J7.1, R63.1
/UART_RX1: R61.1
/UART_TX0: J7.2, R64.1
/UART_TX1: R60.1
/USB_DN: U2.30 (USB2_DM), U13.3 (DN)
/USB_DP: U2.31 (USB2_DP), U13.2 (DP)
/XTAL_IN: C84.1, U2.117 (XTAL_IN), X2.1 (OSC1)
/XTAL_OUT: C83.1, U2.118 (XTAL_OUT), X2.3 (OSC2)
GND: C41.1, C42.2, C78.1, C79.1, C80.1, C81.2, C82.2, C83.2, C84.2, C85.1, C87.2, DF2.6, DF2.21, DF2.22, DF2.27, DF2.28, DF2.29, DF2.30, DF2.31, FB1.2, J4.2, J4.MP (MountPin), J6.5, J6.MP (MountPin), J7.3, J7.MP (MountPin), J8.1, J8.MP (MountPin), R22.2, R49.1, R62.1, R68.2, R70.2, R72.1, R100.1, SD2.6 (VSS), SD2.10, SD2.11, U2.129 (EP), U11.4 (GND), U13.1 (GND), U13.4 (GND), U13.8 (GND), U13.9 (GND), U13.10 (GND), U13.11 (GND), U13.12 (GND), U13.13 (GND), U13.14 (GND), U13.15 (GND), U13.16 (GND), U13.17 (GND), U13.18 (GND), X2.2 (GND), X2.4 (GND); also elsewhere on the board
unnamed: LED10.2 (A), R74.2
unnamed: LED11.1 (C), R21.1
unnamed: LED12.1 (C), R22.1
unnamed: C77.1, U2.33 (AUD_AVG)
unnamed: C77.2, FB1.1, U2.34 (AUD_VRM_ADC)
unnamed: C41.2, C42.1, FB2.2, U2.32 (AVDD_AUD)
unnamed: C80.2, U2.43 (DVDD_DDR_RX)
unnamed: C78.2, U2.73 (DVDD_NODIE)
unnamed: R58.2, U2.90 (FUART_RX)
unnamed: R59.2, U2.91 (FUART_TX)
unnamed: R48.2, U2.64 (PM_GPIO8)
unnamed: R61.2, U2.52 (PM_UART_RX1)
unnamed: R63.2, U2.50 (PM_UART_RX)
unnamed: R60.2, U2.53 (PM_UART_TX1)
unnamed: R64.2, U2.51 (PM_UART_TX)
unnamed: R55.1, U2.10 (SD0_CLK)
unnamed: R47.1, U2.112 (SR0_IO17)
unnamed: R49.2, U2.85 (XTAL_IN_32K)
unnamed: R100.2, U2.86 (XTAL_OUT_32K)
VBUS: J4.1, J6.6; also elsewhere on the board

Notes on the sheet:
MIPI CAMERA
ETH NETWROK
LOW ACTIVE
PM_SPI_WPZ 需一直拉低 PM_SPI_SDO 拉低NAND，拉高NOR FLASH，内部已拉高 PM_SPI_SCK 拉高跳过SD卡检测，快速启动
NOR/NAND SPI FLASH
使用国内社区群友约定线序， 兼容立创开源的openipc摄像头(DF56座子与主板的反序)
SR_VS SR_HS
High Active
DBG-UART
LAN_LINK LAN_ACT
注意核对封装13与14、 26引脚位置同侧。 DJI副厂同轴线中间6脚11-16不通！！！固不使用
SD CARD
FOR DVFS
Не люблю ферриты которые стоят без причины возможно заменить на резистор 60ом и 0ом на питание 3V3 и все как бы но надо думать а думать не любим
WLAN-USB

Parts:
1V1, 1V8, 1V12, 3V3: TestPoint_Pad_D1.0mm
C17: 47p; C_0402_1005Metric
C19, C27, C30, C34, C147, C159: 10u; C_0603_1608Metric
C20, C21: 22u; C_0603_1608Metric
C25: 10u/50V; C_1206_3216Metric; LCSC Part Name C7432781
C31, C32: 22u/35V; C_1206_3216Metric; LCSC Part Name C342620
C33, C35: 10u; C_0603_1608Metric; Manufacturer Part CL10A106MA8NRNC
C63, C70, C71, C88, C149, C152, C154, C155, C157, C158, C160, C161, C162, C166, C167, C168, C169, C170, C171, C172, C173, C174, C175, C176: 100n; C_0402_1005Metric; Manufacturer Part CL05B104KB54PNC
C72: 1u; C_0402_1005Metric; Manufacturer Part CL05B104KB54PNC
C141, C142, C143, C144, C145, C153, C156: 100n; C_0402_1005Metric
H1, H2, H3: MountingHole; MountingHole_2.2mm_M2
L2: 10uH; L_Changjiang_FXL0420; LCSC Part Name C177242
L7, L10, L11: 2.2uH; L_Changjiang_FTC252012S; Manufacturer Part FTC252012S2R2MBCA; LCSC Part Name C5832372
R7, R12, R15, R23, R24: 100k; R_0402_1005Metric
R8: 150k; R_0402_1005Metric
R9: 51K; R_0402_1005Metric
R10: 24k9; R_0402_1005Metric
R14: 20; R_0402_1005Metric
R35: 33k; R_0402_1005Metric
R36: 75k; R_0402_1005Metric
R37: 15k; R_0402_1005Metric
R38: 10k; R_0402_1005Metric
R67: 100; R_0402_1005Metric
U1: TLV74018PDBVR; SOT-23-5; Manufacturer Part TLV74018PDBVR; LCSC Part Name C3746861
U3: MP9943GQ-Z; QFN-8_L3.0-W3.0-P0.65-BL; Manufacturer Part MP9943GQ-Z; LCSC Part Name C51889390
U7: TMI3113B; SOT-23-5; Manufacturer Part TMI3113B; LCSC Part Name C2889165
U14: TMI3411; SOT-23-5; Manufacturer Part TMI3411; LCSC Part Name C478952
U17: TMI3408F; SOT-23-5; Manufacturer Part TMI3408F; LCSC Part Name C5138141

Connections:
+1V0: 1V1.1 (1_1), C17.2, C21.2, C154.2, C157.2, C160.2, C162.2, C166.2, C168.2, C170.2, C172.2, C174.2, C176.2, L7.2, R9.2; also elsewhere on the board
+1V5: 1V8.1 (1_1), C34.2, C147.2, C149.2, C152.2, C155.2, C158.2, L11.2, R37.2; also elsewhere on the board
+1V8: 1V12.1 (1_1), C35.2, U1.5 (OUT); also elsewhere on the board
+3V3: 3V3.1 (1_1), C20.2, C33.2, C153.2, C156.2, C159.2, C161.2, C167.2, C169.2, C171.2, C173.2, C175.2, L10.2, R8.2, U1.1 (IN), U1.3 (EN); also elsewhere on the board
+5V: C19.2, C27.2, C30.2, C31.1, C32.1, C63.2, C70.2, C141.2, C143.2, L2.2, R7.1, R15.1, R23.1, R24.1, U7.4 (IN), U14.4 (VIN), U17.4 (VIN); also elsewhere on the board
/POWER/3V3EN: C72.2, R23.2, R67.1 (1_1), U7.1 (EN)
GND: C19.1, C20.1, C21.1, C25.2, C27.1, C30.1, C31.2, C32.2, C33.1, C34.1, C35.1, C63.1, C70.1, C71.1, C72.1, C88.1, C141.1, C142.1, C144.1, C147.1, C149.1, C152.1, C153.1, C154.1, C155.1, C156.1, C157.1, C158.1, C159.1, C160.1, C161.1, C162.1, C166.1, C167.1, C168.1, C169.1, C170.1, C171.1, C172.1, C173.1, C174.1, C175.1, C176.1, R10.2, R35.1, R36.1, R38.1, U1.2 (GND), U3.5 (GND), U7.2 (GND), U14.2 (GND), U17.2 (GND); also elsewhere on the board
unnamed: C145.2, R14.2
unnamed: R14.1, U3.4 (BST)
unnamed: C143.1, R7.2, R10.1, U3.1 (FB)
unnamed: R12.1, U3.8 (PG)
unnamed: C145.1, L2.1, U3.6 (SW)
unnamed: C144.2, R12.2, U3.2 (VCC)
unnamed: R8.1, R35.2, U7.5 (FB)
unnamed: L10.1, U7.3 (LX)
unnamed: C71.2, R15.2, U14.1 (EN)
unnamed: C17.1, R9.1, R36.2, U14.5 (FB)
unnamed: L7.1, U14.3 (LX)
unnamed: C88.2, R24.2, U17.1 (EN)
unnamed: R37.1, R38.2, U17.5 (FB)
unnamed: L11.1, U17.3 (LX)
VBUS: C25.1, C142.2, U3.3 (EN/SYNC), U3.7 (IN); also elsewhere on the board

Notes on the sheet:
Imax>=0.5A 1.0V±3%
Vout=0.6*(1+R1/R2)=0.6*(1+51/75)=1.0V
Imax>=0.3A 1.5V±3%
Power on sequence , 1.0V no later than 3.3V_SYS. 充电延时=R*C*ln[(V-Ven)/V]
short to gnd for reset

Board: 6 copper layers, 32.0 x 40.0 mm, 132 parts (1 on the bottom side), 86 nets.

File production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
C25,1206,1,10u/50V,
"C31, C32",1206,2,22u/35V,
"C83, C84",0402,2,12p,
DF2,DF56C-26S-0.3V(51),1,DF56C-26S-0.3V(51),
J4,JST_SH_SM04B-SRSS-TB_1x04-1MP_P1.00mm_Horizontal,1,Conn_01x04_MountingPin,
J6,JST_SH_SM06B-SRSS-TB_1x06-1MP_P1.00mm_Horizontal,1,Conn_01x06_MountingPin,
J7,JST_SH_SM03B-SRSS-TB_1x03-1MP_P1.00mm_Horizontal,1,Conn_01x03_MountingPin,
J8,JST_SH_SM02B-SRSS-TB_1x02-1MP_P1.00mm_Horizontal,1,Conn_01x02_MountingPin,
"L10, L11, L7",L_Changjiang_FTC252012S,3,2.2uH,
L2,L_Changjiang_FXL0420,1,10uH,
"LED10, LED11, LED12",0402,3,NCD0402G1,
SD2,TF-SMD_HYCW104-TF08-375B,1,TF-027-H300,
U1,SOT-23-5,1,TLV74018PDBVR,
U11,SOIC-8_L5.3-W5.3-P1.27-LS8.0-BL,1,W25Q128JVSIQ,
U13,BL-M8812EU2,1,BL-M8812EU2,
U14,SOT-23-5,1,TMI3411,
U17,SOT-23-5,1,TMI3408F,
U2,QFN128_12.3_12.3,1,SSC338Q,
U3,QFN-8_L3.0-W3.0-P0.65-BL,1,MP9943GQ-Z,
U7,SOT-23-5,1,TMI3113B,
X2,Crystal_SMD_2016-4Pin_2.0x1.6mm,1,24MHz,
